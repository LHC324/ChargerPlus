# Keil uVision project ChargerPlus.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ChargerPlus +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Inc
  group User
    ./Src/: main.c
  group Hardware
    ./Src/: GPIO.c timer.c usart.c IIC.C SC8913.C charger.c Dwin.c ModbusMaster.c
  group Asm
    ./: STARTUP.A51
  group Redme
    ./Src/: readme.txt
